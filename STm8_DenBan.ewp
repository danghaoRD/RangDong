# IAR project STm8_DenBan.ewp, settings and files
configuration Debug (STM8, debug)
  General.GenDeviceSelectMenu: STM8S207C8 STM8S207C8
  General.GenCodeModel: 0
  General.GenDataModel: 1
  General.GenStackSize: 0x100
  General.GenHeapSize: 0x100
  ICCSTM8.CCDefines: STM8S207
  ICCSTM8.CCIncludePath2: D:\1. DEN BAN CAM UNG\STM8_Code\STM8S_StdPeriph_Driver\inc; D:\1. DEN BAN CAM UNG\STM8_Code\USER; STM8S_StdPeriph_Driver\inc; USER
  ICCSTM8.IccLang: 0
  OBJCOPY.OOCOutputFile: STm8_DenBan.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkStackSize: 1
  ILINK.IlinkHeapSize: 1
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (STM8)
  as the first configuration, except:
  ICCSTM8.CCDefines: NDEBUG
  group Lib
    STM8S_StdPeriph_Driver/src/: stm8s_adc2.c stm8s_awu.c stm8s_beep.c stm8s_clk.c stm8s_exti.c stm8s_flash.c stm8s_gpio.c stm8s_i2c.c stm8s_itc.c stm8s_iwdg.c stm8s_rst.c stm8s_spi.c stm8s_tim1.c stm8s_tim2.c stm8s_tim3.c stm8s_tim4.c stm8s_uart1.c stm8s_uart3.c stm8s_wwdg.c
  group User
    USER/: Button.c DELAY.c LED.c main.c RD_LED_Ctr.c stm8s_it.c UART.c wifimanager.c
  group Wifi
    USER/: mcu_api.c protocol.c system.c
