<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\STm8_DenBan.ewp</path>
    </project>
    <batchBuild />
</workspace>
